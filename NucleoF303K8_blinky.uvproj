# Keil uVision project NucleoF303K8_blinky.uvproj, settings and files
target mbed NUCLEO_F303K8 (ARM-ADS)
  device: STM32F303K8 STMicroelectronics
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00003000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NucleoF303K8_blinky
  c flags: Optim=1
  c define: TARGET_M4,  TARGET_FF_ARDUINO,  __CORTEX_M4,  MBED_BUILD_TIMESTAMP=1447249464.05,  __FPU_PRESENT=1,  TARGET_CORTEX_M,  TOOLCHAIN_ARM_MICRO,  TARGET_STM32F303K8,  TARGET_NUCLEO_F303K8,  __MBED__=1,  TARGET_STM,  TARGET_STM32F3,  TOOLCHAIN_ARM,  ARM_MATH_CM4,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  mbed;  mbed/TARGET_NUCLEO_F303K8;  mbed/TARGET_NUCLEO_F303K8/TARGET_STM;  mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3;  mbed/TARGET_NUCLEO_F303K8/TARGET_STM/TARGET_STM32F3/TARGET_NUCLEO_F303K8;  mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO;
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f303x8.sct
  link misc: mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_smartcard.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/board.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/cmsis_nvic.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/hal_tick.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/mbed_overrides.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/retarget.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/startup_stm32f303x8.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_adc.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_adc_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_can.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_cec.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_comp.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_cortex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_crc.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_crc_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_dac.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_dac_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_dma.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_flash.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_flash_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_gpio.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_hrtim.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_i2c.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_i2c_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_i2s.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_i2s_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_irda.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_iwdg.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_nand.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_nor.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_opamp.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_opamp_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_pccard.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_pcd.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_pcd_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_pwr.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_pwr_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_rcc.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_rcc_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_rtc.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_rtc_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_sdadc.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_smartcard_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_smbus.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_spi.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_sram.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_tim.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_tim_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_tsc.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_uart.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_uart_ex.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_usart.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_hal_wwdg.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/stm32f3xx_ll_fmc.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/sys.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/system_stm32f3xx.o
            
              mbed/TARGET_NUCLEO_F303K8/TOOLCHAIN_ARM_MICRO/mbed.ar
  group src
    ./: main.cpp
